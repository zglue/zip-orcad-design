* Auto-Generated SPICE Netlist
* Design: zip_design_example.dsn
* Date: 06/16/2020, Time: 11:23:22

.SUBCKT BONDPAD 1
*.PININFO 1:1
.ENDS

.SUBCKT MC3672 D2 B2 E1 A1 C1 E3 C3 A3
*.PININFO D2:DOUT_A1 B2:DIN_SDA E1:VPP A1:INTN C1:VDD E3:GND C3:CSN A3:SCK_SCL
.ENDS

.SUBCKT DA14585 A7 B7 B6 C6 C7 D6 D7 E7 E6 F7 F6 A5 A4 A3 B4 D4 D3 C3 F3 E4 F4 E3 A2 E2 D2 C2 B2 F2 A1 B1 E1 D1 C1 F1
*.PININFO A7:VDD B7:P0_0 B6:P0_1 C6:P0_2 C7:P0_3 D6:P0_4 D7:P0_5 E7:P0_6 E6:P0_7 F7:XTAL32Km F6:XTAL32Kp A5:GND1 A4:RFIOp A3:RFIOm B4:GND2 D4:GND5 D3:GND4 C3:GND3 F3:GND6 E4:VBAT_RF F4:VBAT3V E3:RST A2:VDCDC_RF E2:P1_0 D2:P1_1 C2:P1_2 B2:P1_3 F2:VDCDC A1:XTAL16Mm B1:XTAL16Mp E1:VBAT1V D1:SWDIO C1:SW_CLK F1:SWITCH
.ENDS

.SUBCKT SmartFabric 1 2 3 4 6 5 7 8 9 10 11 12 14 13 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73 74 75 76 77 78 79 80 81 82 83 84 85 86 87 88 89 90 91 92 93 94 95
*.PININFO 1:ZIP_CS 2:ZIP_SCLK 3:ZIP_MOSI 4:ZIP_MISO 6:ZIP_SDA 5:ZIP_SCL 7:FAULT_INT 8:MCU_RST 9:ULPM_WAKE 10:VBATH 11:SYSLDO_OUT 12:ZIP_EN_H 14:ZIP_EN_L 13:ZIP_EN_OUT 15:VBATL 16:VBATL_SW 17:VX 18:BOOST_OUT 19:BOOST_GND 20:LDOx_IN 21:LDO1_OUT 22:LDO2_OUT 23:LDO3_OUT 24:VDDANA 25:VDDIO 26:VRAIL1 27:VRAIL2 28:VBAT_SNS 29:GND 30:GPIO_EXP_INT 31:GPIO0 32:GPIO1 33:GPIO2 34:GPIO3 35:GPIO4 36:GPIO5 37:GPIO6 38:GPIO7 39:ISINK1 40:ISINK2 41:ISINK3 42:VCCA1 43:VCCA2 44:VCCA3 45:VCCB1 46:VCCB2 47:VCCB3 48:LS1_A1 49:LS1_A2 50:LS1_A3 51:LS1_A4 52:LS1_A5 53:LS1_A6 54:LS1_A7 55:LS1_A8 56:LS1_B1 57:LS1_B2 58:LS1_B3 59:LS1_B4 60:LS1_B5 61:LS1_B6 62:LS1_B7 63:LS1_B8 64:LS2_A1 65:LS2_A2 66:LS2_A3 67:LS2_A4 68:LS2_A5 69:LS2_A6 70:LS2_A7 71:LS2_A8 72:LS2_B1 73:LS2_B2 74:LS2_B3 75:LS2_B4 76:LS2_B5 77:LS2_B6 78:LS2_B7 79:LS2_B8 80:LS3_A1 81:LS3_A2 82:LS3_A3 83:LS3_A4 84:LS3_A5 85:LS3_A6 86:LS3_A7 87:LS3_A8 88:LS3_B1 89:LS3_B2 90:LS3_B3 91:LS3_B4 92:LS3_B5 93:LS3_B6 94:LS3_B7 95:LS3_B8
.ENDS

.SUBCKT BMM150 E1 E3 D2 D4 E5 C5 A5 B4 A3 B2 A1 C1
*.PININFO E1:GND_2 E3:GND_3 D2:INT D4:DRDY E5:VDD C5:GND_1 A5:CSB B4:SDI A3:SCK B2:VDDIO A1:PS C1:SDO
.ENDS

BP8 CLKp_32K BONDPAD
U3 SPI_MISO SPI_MOSI GND ACC_nINT VDD3V3 GND SPI_SS SPI_SCK MC3672
BP4 RFIPm BONDPAD
BP2 SPI_SCK BONDPAD
BP5 RFIOp BONDPAD
BP9 SWCLK BONDPAD
U2 UN32767 SCL_3V3 SDA_3V3 INT_3V3 SPI_SCK SPI_MOSI SPI_MISO SPI_SS ACC_nINT UN32766 CLKp_32K GND RFIOp RFIPm GND GND GND GND GND VDD3V3 VDD3V3 RST VDCDC_RF UN32765 UN32764 UN32763 UN32762 VDCDC CLKm_16K CLKp_16K GND SWDIO SWCLK SWITCH DA14585
BP3 VDCDC_RF BONDPAD
BP1 DRDY BONDPAD
S1 UN32761 UN32760 UN32759 UN32758 SDA_3V3 SCL_3V3 UN32757 RST UN32756 VBAT VSYS VBAT UN32755 UN32754 GND UN32753 UN32752 UN32751 GND VSYS VDD3V3 VDD1V8 UN32750 VBAT VSYS VDD3V3 VDD1V8 UN32749 GND UN32748 UN32747 UN32746 UN32745 UN32744 UN32743 UN32742 UN32741 UN32740 UN32739 UN32738 UN32737 VDD3V3 UN32736 UN32735 VDD1V8 UN32734 UN32733 SCL_3V3 SDA_3V3 INT_3V3 UN32732 UN32731 UN32730 UN32729 UN32728 SCL_1V8 SDA_1V8 INT_1V8 UN32727 UN32726 UN32725 UN32724 UN32723 UN32722 UN32721 UN32720 UN32719 UN32718 UN32717 UN32716 UN32715 UN32714 UN32713 UN32712 UN32711 UN32710 UN32709 UN32708 UN32707 UN32706 UN32705 UN32704 UN32703 UN32702 UN32701 UN32700 UN32699 UN32698 UN32697 UN32696 UN32695 UN32694 UN32693 UN32692 UN32691 SmartFabric
RP3 RST VDD3V3 10k
RP1 SCL_3V3 VDD3V3 3.3k
BP11 VDCDC BONDPAD
BP6 CLKm_16K BONDPAD
BP12 SWITCH BONDPAD
BP10 SWDIO BONDPAD
RP4 ACC_nINT VDD3V3 10k
U1 GND GND INT_1V8 DRDY VDD1V8 GND GND SDA_1V8 SCL_1V8 VDD1V8 VDD1V8 GND BMM150
BP7 CLKp_16K BONDPAD
RP2 SDA_3V3 VDD3V3 3.3k
* Total parsed components: 20
.END
