* Auto-Generated SPICE Netlist
* Design: zip_design_example.dsn
* Date: 05/26/2020, Time: 14:08:03

.SUBCKT PowerManagement 10 12 11 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29
*.PININFO 10:VBATH 12:VBATL 11:SYSLDO_OUT 13:BOOST_OUT 14:ZIP_EN_H 15:ZIP_EN_L 16:ZIP_EN_OUT 17:LDOx_IN 18:LDO1_OUT 19:LDO2_OUT 20:LDO3_OUT 21:VRAIL1 22:VRAIL2 23:VBAT_SENSE 24:GND 25:BOOST_GND 26:VDDANA 27:VDDIO 28:VBATL_SW 29:VX
.END

.SUBCKT DA14585 A7 B7 B6 C6 C7 D6 D7 E7 E6 F7 F6 A5 A4 A3 B4 D4 D3 C3 F3 E4 F4 E3 A2 E2 D2 C2 B2 F2 A1 B1 E1 D1 C1 F1
*.PININFO A7:VDD B7:P0_0 B6:P0_1 C6:P0_2 C7:P0_3 D6:P0_4 D7:P0_5 E7:P0_6 E6:P0_7 F7:XTAL32Km F6:XTAL32Kp A5:GND1 A4:RFIOp A3:RFIOm B4:GND2 D4:GND5 D3:GND4 C3:GND3 F3:GND6 E4:VBAT_RF F4:VBAT3V E3:RST A2:VDCDC_RF E2:P1_0 D2:P1_1 C2:P1_2 B2:P1_3 F2:VDCDC A1:XTAL16Mm B1:XTAL16Mp E1:VBAT1V D1:SWDIO C1:SW_CLK F1:SWITCH
.END

.SUBCKT LEDDriver 39 40 41
*.PININFO 39:ISINK1 40:ISINK2 41:ISINK3
.END

.SUBCKT BMM150 E1 E3 D2 D4 E5 C5 A5 B4 A3 B2 A1 C1
*.PININFO E1:GND_2 E3:GND_3 D2:INT D4:DRDY E5:VDD C5:GND_1 A5:CSB B4:SDI A3:SCK B2:VDDIO A1:PS C1:SDO
.END

.SUBCKT LevelShifter1 42 51 43 44 45 46 47 48 49 50 52 53 54 55 56 57 58 59
*.PININFO 42:VCCA1 51:VCCB1 43:LS1_A1 44:LS1_A2 45:LS1_A3 46:LS1_A4 47:LS1_A5 48:LS1_A6 49:LS1_A7 50:LS1_A8 52:LS1_B1 53:LS1_B2 54:LS1_B3 55:LS1_B4 56:LS1_B5 57:LS1_B6 58:LS1_B7 59:LS1_B8
.END

.SUBCKT GPIOExpander 30 31 32 33 34 35 36 37 38
*.PININFO 30:GPIO_EXP_INT 31:GPIO0 32:GPIO1 33:GPIO2 34:GPIO3 35:GPIO4 36:GPIO5 37:GPIO6 38:GPIO7
.END

.SUBCKT MC3672 D2 B2 E1 A1 C1 E3 C3 A3
*.PININFO D2:DOUT_A1 B2:DIN_SDA E1:VPP A1:INTN C1:VDD E3:GND C3:CSN A3:SCK_SCL
.END

.SUBCKT LevelShifter2 60 69 61 62 63 64 65 66 67 68 70 71 72 73 74 75 76 77
*.PININFO 60:VCCA2 69:VCCB2 61:LS2_A1 62:LS2_A2 63:LS2_A3 64:LS2_A4 65:LS2_A5 66:LS2_A6 67:LS2_A7 68:LS2_A8 70:LS2_B1 71:LS2_B2 72:LS2_B3 73:LS2_B4 74:LS2_B5 75:LS2_B6 76:LS2_B7 77:LS2_B8
.END

.SUBCKT Interface 1 2 3 4 5 6 7 8 9
*.PININFO 1:ZIP_CS 2:ZIP_SCLK 3:ZIP_MOSI 4:ZIP_MISO 5:ZIP_SCL 6:ZIP_SDA 7:FAULT_INT 8:MCU_RST 9:ULPM_WAKE
.END

.SUBCKT LevelShifter3 78 87 79 80 81 82 83 84 85 86 88 89 90 91 92 93 94 95
*.PININFO 78:VCCA3 87:VCCB3 79:LS3_A1 80:LS3_A2 81:LS3_A3 82:LS3_A4 83:LS3_A5 84:LS3_A6 85:LS3_A7 86:LS3_A8 88:LS3_B1 89:LS3_B2 90:LS3_B3 91:LS3_B4 92:LS3_B5 93:LS3_B6 94:LS3_B7 95:LS3_B8
.END

S1-2 VBAT GND VSYS UN32767 VBAT UN32766 UN32765 VSYS VDD3V3 VDD1V8 UN32764 VDD3V3 VDD1V8 UN32763 GND GND VBAT VSYS UN32762 UN32761 PowerManagement
BP1 DRDY BONDPAD
U2 UN32760 SCL_3V3 SDA_3V3 INT_3V3 SPI_SCK SPI_MOSI SPI_MISO SPI_SS UN32759 UN32758 UN32757 GND UN32756 UN32755 GND GND GND GND GND VDD3V3 VDD3V3 RST VDCDC_RF UN32754 UN32753 UN32752 UN32751 UN32750 UN32749 UN32748 UN32747 UN32746 UN32745 UN32744 DA14585
BP3 VDCDC_RF BONDPAD
S1-4 UN32743 UN32742 UN32741 LEDDriver
U1 GND GND INT_1V8 DRDY VDD1V8 GND GND SDA_1V8 SCL_1V8 VDD1V8 VDD1V8 GND BMM150
RP1 SCL_3V3 VDD3V3 3.3k
S1-5 VDD3V3 VDD1V8 SCL_3V3 SDA_3V3 INT_3V3 UN32740 UN32739 UN32738 UN32737 UN32736 SCL_1V8 SDA_1V8 INT_1V8 UN32735 UN32734 UN32733 UN32732 UN32731 LevelShifter1
S1-3 UN32730 UN32729 UN32728 UN32727 UN32726 UN32725 UN32724 UN32723 UN32722 GPIOExpander
RP3 RST VDD3V3 10k
U3 SPI_MISO SPI_MOSI GND UN32721 VDD3V3 GND SPI_SS SPI_SCK MC3672
RP2 SDA_3V3 VDD3V3 3.3k
S1-6 UN32720 UN32719 UN32718 UN32717 UN32716 UN32715 UN32714 UN32713 UN32712 UN32711 UN32710 UN32709 UN32708 UN32707 UN32706 UN32705 UN32704 UN32703 LevelShifter2
BP2 SPI_SCK BONDPAD
S1-1 UN32702 UN32701 UN32700 UN32699 SCL_3V3 SDA_3V3 UN32698 RST UN32697 Interface
S1-7 UN32696 UN32695 UN32694 UN32693 UN32692 UN32691 UN32690 UN32689 UN32688 UN32687 UN32686 UN32685 UN32684 UN32683 UN32682 UN32681 UN32680 UN32679 LevelShifter3
* Total parsed components: 16
.END
